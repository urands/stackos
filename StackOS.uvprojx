# Keil uVision project StackOS.uvprojx, settings and files
target Debug (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: StackOS +hex
  c flags: Optim=1 wLevel=2
  c include: .\Core;.\RTE;.\Modules
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StackOS
    ./Core/: Core.c StackOS.h
    ./Core/src/: StackOS_Function.c StackOS_Route.c
  group Toolbox
    ./Modules/Toolbox/: Toolbox.h
  group Pattern
    ./Modules/Pattern/: Pattern.h
    ./Modules/Pattern/src/: PatternTestBench.c Pattern.c
software components: CMSIS:CORE 3.20.0, CMSIS:DSP 1.4.1, CMSIS:RTOS:Keil RTX 4.74.0, Device:DMA 1.01.0, Device:GPIO 1.01.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Drivers:UART 1.01.0
